VERSION 5.7 ;
  NOWIREEXTENSIONATPIN ON ;
  DIVIDERCHAR "/" ;
  BUSBITCHARS "[]" ;
MACRO dieart_tl
  CLASS BLOCK ;
  FOREIGN dieart_tl ;
  ORIGIN 0.000 0.000 ;
  SIZE 143.25 BY 143.25 ;
  OBS
      LAYER Metal1 ;
        RECT 0.0 0.0 143.25 143.25 ;
      LAYER Metal2 ;
        RECT 0.0 0.0 143.25 143.25 ;
      LAYER Metal3 ;
        RECT 0.0 0.0 143.25 143.25 ;
      LAYER Metal4 ;
        RECT 0.0 0.0 143.25 143.25 ;
      LAYER Metal5 ;
        RECT 0.0 0.0 143.25 143.25 ;
  END
END dieart_tl
END LIBRARY
